# Keil uVision project STM32F407.uvprojx, settings and files
target Liam (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output E:\My_Project\STM32F407\keil-project\Objects\STM32F407.bin E:\My_Project\STM32F407\keil-project\Objects\STM32F407.axf
  AfterMake: E:\My_Project\STM32F407\keil-project\CleanObjFiles.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\cmsis;..\cmsis\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../app/: main.c sysconfig.c usart.c exti.c
  group CMSIS
    ../cmsis/: system_stm32f4xx.c stm32f4xx_it.c startup_stm32f40_41xxx.s
  group STD-PERIPH
    ../cmsis/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c
